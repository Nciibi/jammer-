<?xml version='1.0' encoding='utf-8'?>
<?grc format='2'?>
<flow_graph>
<block>
<key>type</key>
<param><key>id</key><value>noise_source</value></param>
<param><key>noise_type</key><value>gaussian</value></param>
<param><key>amplitude</key><value>1.0</value></param>
<param><key>samp_rate</key><value>10e6</value></param>
</block>
<block>
<key>type</key>
<param><key>device_addr</key><value>type=b200</value></param>
<param><key>center_freq</key><value>2.437e9</value></param>
<param><key>samp_rate</key><value>10e6</value></param>
<param><key>gain</key><value>25</value></param>
<param><key>ant</key><value>TX/RX</value></param>
</block>
<connection><source_block_id></source_block_id><sink_block_id></sink_block_id><source_key></source_key><sink_key></sink_key></connection>
</flow_graph>
